File: schemata_kicad/DC_offset.kicad_sch (KiCad schematic)
At the start: 15 parts

Commit message: update
Parts:
- U? (x3): value ~ -> (none)
