File: schemata_kicad/peak_detect.kicad_sch (KiCad schematic)
At the start: 5 parts, among them Q1 MOSFET, U6 VSIN

Commit message: update
Parts:
- U5: value ~ -> (none)
